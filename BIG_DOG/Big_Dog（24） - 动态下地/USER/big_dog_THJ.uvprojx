# Keil uVision project big_dog_THJ.uvprojx, settings and files
target SMALL_DOG (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: small_dog_THJ
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,__FPU_PRESENT=1,ARM_MATH_CM4,__FPU_USED =1,
  c include: ..\USER;..\SYSTEM;..\HARDWORK;..\FWLIB\inc;..\CORE;..\FreeRTOS\include;..\FreeRTOS\port\RVDS\ARM_CM4F
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CORE
    ../CORE/: startup_stm32f407xx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group FreeRTOS/port
    ../FreeRTOS/port/MemMang/: heap_4.c
    ../FreeRTOS/port/RVDS/ARM_CM4F/: port.c
  group FreeRTOS/inc
    ../FreeRTOS/src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group SYSTEM
    ../SYSTEM/: delay.c delay.h sys.c sys.h
  group USER
    ./: main.c main.h stm32f4xx_it.c system_stm32f4xx.c FreeRTOSConfig.h
  group BaseHardwork
    ../HARDWORK/: BEEP.c BEEP.h Laser.c Laser.h LED.c LED.h tim9.c tim9.h spi.c spi.h kalman.c kalman.h i2c.c i2c.h
  group ApplicationHardwork
    ../HARDWORK/: APP_task.c APP_task.h DR16.c DR16.h USART.c USART.h foc.c foc.h CAN.c CAN.h Steering.c Steering.h BMI088.c BMI088.h ist8310.c ist8310.h imu.c imu.h move_control.c move_control.h gait.c gait.h
